# Keil uVision project TML.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC2132/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: TML
  group ADS1247
    ./: ads1247.c
  group MAIN
    ./: main.c Startup.s
  group AD5422
    ./: ad5422.c
  group Modbus_RTU
    ./modbus/: mb.c
    ./modbus/rtu/: mbcrc.c mbfuncholding.c mbrtu.c port.c portevent.c portserial.c porttimer.c mbutils.c
  group DS18B20
    ./: DS18B20.c
  group NVS
    ./NVS/: armint.c flash_nvol.c
  group RTC
    ./: rtc.c
